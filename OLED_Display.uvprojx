# Keil uVision project OLED_Display.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: OLED_Display +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Src
    ./: main.c GPIO.c I2C_2.c System_RCC.c SSD1306.c Font.c
  group Inc
    ./: GPIO.h System_RCC.h I2C_2.h SSD1306.h Font.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.4.2
